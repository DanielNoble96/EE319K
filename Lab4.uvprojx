# Keil uVision project Lab4.uvprojx, settings and files
target Lab4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab4
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Code
    ./: Startup.s SysTick.s main.s TExaS.c
    ../SysTick_4C123asm/: PLL.asm
software components: CMSIS:CORE 4.3.0
